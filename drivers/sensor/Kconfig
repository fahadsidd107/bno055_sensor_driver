## drivers/sensor/bno055/Kconfig
```kconfig
config BNO055
	bool "Bosch Sensortec MEMS BNO055"
	depends on I2C
	help
	  Enable driver for BNO055 sensor.
```
